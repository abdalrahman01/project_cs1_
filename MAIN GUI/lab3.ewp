# IAR project lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microchip\sam3x8\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: calendar.h calender.c commands_data_lcd.h GPIO_config.c GPIO_config.h main.c
    GUI/: GUI.c GUI.h GUI_constants.h GUI_controls.c GUI_controls.h GUI_data.c GUI_data.h GUI_views.c GUI_views.h
  group keypad_display
    ./: keypad.c keypad.h LCD.c LCD.h lcd_commands.c lcd_commands.h lcd_keypad_buss.h
  group light_sensor
    ./: light_sensor.c light_sensor.h
  group servo
    ./: servo.c servo.h
  group startup_files
    startup_files/: at91sam3x8.h exceptions.c startup_sam3x.c system_sam3x.c
  group temp_sensor
    ./: temp_sensor.c temp_sensor.h
